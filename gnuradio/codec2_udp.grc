options:
  parameters:
    author: Fabian Mink
    category: Custom
    generate_options: qt_gui
    id: loopback_codec2
    output_language: python
    title: Codec2 UDP Test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: scale
  id: variable
  parameters:
    value: 2**13
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: scale
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: scale
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: byte
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '64'
    port: '2000'
    send_eof: 'False'
    type: byte
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '64'
    port: '2000'
    src_zeros: 'False'
    type: byte
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: in
    label2: out
    name: Audio
    nconnections: '2'
    size: '1024'
    srate: '8000'
    type: float
    ylabel: audio
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    fbw: '0.4'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.4'
    interp: '6'
    taps: ''
    type: fff
  states: {}
- name: vocoder_codec2_decode_ps_0
  id: vocoder_codec2_decode_ps
  parameters:
    mode: codec2.MODE_3200
  states: {}
- name: vocoder_codec2_encode_sp_0
  id: vocoder_codec2_encode_sp
  parameters:
    mode: codec2.MODE_3200
  states: {}

connections:
- [audio_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_short_0, '0', vocoder_codec2_encode_sp_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0_1, '1']
- [blocks_short_to_float_0, '0', rational_resampler_xxx_1, '0']
- [blocks_stream_to_vector_0, '0', vocoder_codec2_decode_ps_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', network_udp_sink_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [network_udp_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_short_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0_1, '0']
- [rational_resampler_xxx_1, '0', audio_sink_0, '0']
- [vocoder_codec2_decode_ps_0, '0', blocks_short_to_float_0, '0']
- [vocoder_codec2_encode_sp_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
